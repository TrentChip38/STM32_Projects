# Keil uVision project MicroLab7.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: MicroLab7
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6314W
  group Source Group 1
    ../../Downloads/Lab04_LCD (1)/: startup_stm32l476xx.s stm32l476xx.h
    ./: main.c SysTick.c SysTick.h StepMotor.h StepMotor.c KeyPad.c KeyPad.h
software components: CMSIS:CORE 6.1.0
